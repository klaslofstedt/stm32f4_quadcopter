# IAR project Backup of RTOSDemo.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; USE_DMP; MPL_LOG_NDEBUG=1; EMPL; MPU6050; EMPL_TARGET_STM32F4
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ; board\; Libraries\CMSIS\Device\ST\STM32F4xx\Include; Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\Source\include; ..\..\Source\portable\IAR\ARM_CM4F; ..\Common\include; user\inc; user\src; stm32f4xx\inc; stm32f4xx\src; startup\inc; startup\src; core\driver\include; core\driver\eMPL; core\driver\stm32l; core\mllite; core\mpl; core\eMPL-hal
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: 
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group core/driver/eMPL
    core/driver/eMPL/: dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h
  group core/driver/include
    core/driver/include/: log.h mlinclude.h mlmath.h mlos.h mltypes.h mpu.h stdint_invensense.h
  group core/driver/stm32L
    core/driver/stm32L/: log_stm32.c packet.h
  group core/eMPL-hal
    core/eMPL-hal/: eMPL_outputs.c eMPL_outputs.h
  group core/mllite
    core/mllite/: data_builder.c data_builder.h hal_outputs.c hal_outputs.h invensense.h message_layer.c message_layer.h ml_math_func.c ml_math_func.h mlmath.c mpl.c mpl.h results_holder.c results_holder.h start_manager.c start_manager.h storage_manager.c storage_manager.h
  group core/mpl
    core/mpl/: accel_auto_cal.h compass_vec_cal.h fast_no_motion.h fusion_9axis.h gyro_tc.h heading_from_gyro.h inv_math.h invensense_adv.h libmpllib.a mag_disturb.h motion_no_motion.h no_gyro_fusion.h quaternion_supervisor.h
  group freertos/inc
    ./: FreeRTOSConfig.h
  group freertos/Portable
    ../../Source/portable/IAR/ARM_CM4F/: portasm.s
  group freertos/Portable/src
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/portable/IAR/ARM_CM4F/: port.c
  group freertos/src
    ../../Source/: list.c queue.c tasks.c timers.c
  group stm32f4xx/board/inc
    board/: arm_comm.h iar_stm32f407zg_sk.h
  group stm32f4xx/board/src
    board/: iar_stm32f407zg_sk.c
  group stm32f4xx/startup
    ./: RegTest.s
    startup/: startup_stm32f4xx.s
  group stm32f4xx/startup/inc
    Libraries/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
    ./: stm32f4xx_conf.h stm32f4xx_it.h
  group stm32f4xx/startup/src
    ./: stm32f4xx_it.c
    startup/: system_stm32f4xx.c
  group stm32f4xx/drivers/inc
    Libraries/STM32F4xx_StdPeriph_Driver/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group stm32f4xx/drivers/src
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c
    stm32f4xx/src/: stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group user/inc
    user/inc/: board-st_discovery.h discover_board.h gpio.h i2c.h main.h platform_defaults.h printf2.h uart.h
    ../Common/include/: flash.h partest.h
  group user/src
    ../Common/Minimal/: flash.c
    user/src/: gpio.c i2c.c printf2.c uart.c
    ./: main.c ParTest.c
