# IAR project RTOSDemo.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; USE_DMP; MPL_LOG_NDEBUG=1; EMPL; MPU6050; EMPL_TARGET_STM32F4; xDEBUG; ARM_MATH_CM4; USE_I2C_2V8; configASSERT_DEFINED
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; stm32f4xx; stm32f4xx\drivers\inc; stm32f4xx\drivers\src; stm32f4xx\startup; stm32f4xx\startup\inc; stm32f4xx\startup\src; freertos; freertos\inc; freertos\src; user\inc; user\src; stm32f4xx\inc; stm32f4xx\src; startup\inc; startup\src; invensense_dmp\driver\include; invensense_dmp\driver\eMPL; invensense_dmp\driver\stm32l; invensense_dmp\mllite; invensense_dmp\mpl; invensense_dmp\eMPL-hal; vl53l0x\inc; vl53l0x\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: 
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: FreeRTOSConfig.h
  group freertos
    freertos/: portasm.s
  group freertos/inc
    freertos/inc/: event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group freertos/src
    freertos/src/: event_groups.c heap_2.c list.c port.c queue.c tasks.c timers.c
  group invensense_dmp/driver/eMPL
    invensense_dmp/driver/eMPL/: dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h
  group invensense_dmp/driver/include
    invensense_dmp/driver/include/: log.h mlinclude.h mlmath.h mlos.h mltypes.h mpu.h stdint_invensense.h
  group invensense_dmp/eMPL-hal
    invensense_dmp/eMPL-hal/: eMPL_outputs.c eMPL_outputs.h
  group invensense_dmp/mllite
    invensense_dmp/mllite/: data_builder.c data_builder.h hal_outputs.c hal_outputs.h invensense.h message_layer.c message_layer.h ml_math_func.c ml_math_func.h mlmath.c mpl.c mpl.h results_holder.c results_holder.h start_manager.c start_manager.h storage_manager.c storage_manager.h
  group invensense_dmp/mpl
    invensense_dmp/mpl/: accel_auto_cal.h compass_vec_cal.h fast_no_motion.h fusion_9axis.h gyro_tc.h heading_from_gyro.h inv_math.h invensense_adv.h libmpllib.a mag_disturb.h motion_no_motion.h no_gyro_fusion.h quaternion_supervisor.h
  group stm32f4xx/drivers/inc
    stm32f4xx/drivers/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group stm32f4xx/drivers/src
    stm32f4xx/drivers/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group stm32f4xx/startup
    stm32f4xx/startup/: RegTest.s startup_stm32f4xx.s
  group stm32f4xx/startup/inc
    stm32f4xx/startup/inc/: stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.h system_stm32f4xx.h
  group stm32f4xx/startup/src
    stm32f4xx/startup/src/: stm32f4xx_it.c system_stm32f4xx.c
  group user/inc
    user/inc/: adc.h altitude.h arm.h barometer.h board.h buzzer.h debug.h discover_board.h esc.h filter.h freertos_time.h hardware.h i2c.h i2c_1.h imu.h joystick.h kalman.h laser.h lidar.h main.h motordriver.h pid.h pwm.h tiny_ekf.h uart.h ultrasonic.h
  group user/src
    user/src/: adc.c altitude.c application_hooks.c arm.c barometer.c buzzer.c debug.c esc.c filter.c freertos_time.c hardware.c i2c.c i2c_1.c imu.c joystick.c kalman.c laser.c lidar.c main.c motordriver.c pid.c pwm.c reg_test.c tiny_ekf.c uart.c ultrasonic.c
  group vl53l0x/inc
    vl53l0x/inc/: vl53l0x.h vl53l0x_api.h vl53l0x_api_calibration.h vl53l0x_api_core.h vl53l0x_api_ranging.h vl53l0x_api_strings.h vl53l0x_def.h vl53l0x_device.h vl53l0x_i2c_platform.h vl53l0x_interrupt_threshold_settings.h vl53l0x_platform.h vl53l0x_platform_log.h vl53l0x_tuning.h vl53l0x_types.h
  group vl53l0x/src
    vl53l0x/src/: vl53l0x.c vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_i2c_comms.c vl53l0x_platform.c
